# Keil uVision project scheduler.uvproj, settings and files
target Scheduler (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: scheduler +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC
  group Main
    ./Src/: main.c STARTUP.A51
    ./Src/scheduler/: scheduler.c interrupt_entry.a51
    ./Src/stc/: delay.c timer.c
    ./Src/display/: seg_led.c
    ./Src/memcpy/: memcpy.c
